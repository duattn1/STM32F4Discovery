# Keil uVision project STM32F407VG_Sample.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VG_Sample
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GPIO_SAMPLE, UNIT_TEST_RUNNING
  c include: .\Include;.\UnityLibrary;.\UnitTest_Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Include
    ./Include/: gpio_driver.h header_template.txt rcc_driver.h sample_switch.h main.h
  group Source
    ./Source/: gpio_driver.c main.c rcc_driver.c sample_switch.c source_template.txt
  group UnitTest_Include
    ./UnitTest_Include/: ut_main.h ut_gpio_driver.h ut_base.h
  group UnitTest_Source
    ./UnitTest_Source/: ut_gpio_driver.c ut_main.c ut_base.c
  group UnityLibrary
    ./UnityLibrary/: unity.c unity.h unity_internals.h
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
